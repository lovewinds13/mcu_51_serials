# Keil uVision project mcu_51_serials.uvproj, settings and files
target mcu_51_serials (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: mcu_51_serials +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\app\inc;..\driver\inc;..\user\inc
  group user
    ./: STARTUP.A51
    ../user/src/: main.c
  group driver
    ../driver/src/: ds1302.c lcd_4line.c
